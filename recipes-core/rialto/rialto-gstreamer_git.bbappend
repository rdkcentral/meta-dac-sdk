DEPENDS_remove = "wpeframework-clientlibraries"
DEPENDS += "wpeframework-ocdm-headers"

# 30 Mar 2023
SRCREV = "59b3272f17885542422fc4a95a2477dc2cb054d0"
