FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0003-Make-it-working-on-RDK-based-build.patch"
