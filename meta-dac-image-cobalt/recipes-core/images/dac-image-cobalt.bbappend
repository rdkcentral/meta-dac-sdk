IMAGE_INSTALL += "cobalt-keymap"
