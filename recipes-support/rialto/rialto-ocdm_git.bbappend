RIALTO_OCDM_VERSION = "${RDK7_RIALTO_OCDM_VERSION}"
