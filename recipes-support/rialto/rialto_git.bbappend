RIALTO_VERSION = "${RDK7_RIALTO_VERSION}"
