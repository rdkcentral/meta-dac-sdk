RIALTO_GSTREAMER_VERSION = "${RDK7_RIALTO_GSTREAMER_VERSION}"
