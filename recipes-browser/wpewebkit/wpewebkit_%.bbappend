DEPENDS:remove:qemux86-64 = "qtbase"
DEPENDS:remove:qemux86-64 = "qtbase-native"
