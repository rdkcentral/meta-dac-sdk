require ${@bb.utils.contains('DISTRO_FEATURES', 'igalia-wpe', '', 'cog.inc', d)}
