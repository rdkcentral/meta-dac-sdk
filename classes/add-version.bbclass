#sub class implementation for build to succeed
