require cobalt_dac.inc
SRC_URI += "file://0002-remove-rfc-api-24.patch;patchdir=${WORKDIR}/starboard"
