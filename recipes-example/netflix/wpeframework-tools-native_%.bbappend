SRC_URI_remove = "git://github.com/rdkcentral/Thunder.git;protocol=git;branch=R2;name=thunder"
SRC_URI += "git://github.com/rdkcentral/Thunder.git;protocol=https;branch=R2;name=thunder"
