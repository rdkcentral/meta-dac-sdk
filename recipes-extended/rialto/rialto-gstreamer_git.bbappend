DEPENDS:remove = "wpeframework-clientlibraries"
DEPENDS += "wpeframework-ocdm-headers"

PV = "1.0+git${SRCPV}"
