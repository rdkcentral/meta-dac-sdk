DEPENDS:remove = "wpeframework-clientlibraries"
DEPENDS += "wpeframework-ocdm-headers"

