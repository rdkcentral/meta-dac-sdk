SRC_URI_remove = "git://github.com/rdkcentral/Thunder.git;protocol=git;branch=R4;name=thunder"
SRC_URI += "git://github.com/rdkcentral/Thunder.git;protocol=https;branch=R4;name=thunder"
