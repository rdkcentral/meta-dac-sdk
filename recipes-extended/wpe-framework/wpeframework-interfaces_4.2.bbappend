SRC_URI:remove = "file://r4.2/0001-RDKV-48604-User-Settings-Thunder-Plugin.patch"
