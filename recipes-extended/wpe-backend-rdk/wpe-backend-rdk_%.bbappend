PACKAGECONFIG:remove = "gamepad"
