SRC_URI_remove = "git://github.com/google/googletest.git;destsuffix=git/src/testing/gtest;name=gtest"
SRC_URI += "git://github.com/google/googletest.git;branch=main;destsuffix=git/src/testing/gtest;name=gtest"


